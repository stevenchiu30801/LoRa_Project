# Keil uVision project SX1276_SMS.uvprojx, settings and files
target SX1276_SMS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RE STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: CPUTYPE("Cortex-M3")
  output: SX1276_SMS
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c misc: -DDEVICE_RTC=1 -DDEVICE_SLEEP=1 -DTOOLCHAIN_object -DTOOLCHAIN_ARM_STD --split_sections -D__ASSERT_MSG -DTARGET_RELEASE --no_rtti -DMBED_BUILD_TIMESTAMP=1510775275.07 -DTARGET_NUCLEO_L152RE -DDEVICE_PORTINOUT=1 -D__CORTEX_M3 -DDEVICE_I2C_ASYNCH=1 -DTARGET_FF_ARDUINO -c -DDEVICE_SPISLAVE=1 -DDEVICE_PORTOUT=1 -DDEVICE_STDIO_MESSAGES=1 -DDEVICE_ANALOGOUT=1 -DTARGET_LIKE_MBED -DARM_MATH_CM3 -DTARGET_LIKE_CORTEX_M3 -DDEVICE_ANALOGIN=1 -DDEVICE_PORTIN=1 -DTARGET_CORTEX_M -DDEVICE_SERIAL_FC=1 --cpu=Cortex-M3 -DTARGET_FF_MORPHO -DDEVICE_I2C=1 --preinclude=mbed_config.h -DDEVICE_LOWPOWERTIMER=1 -DTARGET_STM -DTOOLCHAIN_ARM -DDEVICE_INTERRUPTIN=1 --no_depend_system_headers -DTARGET_UVISOR_UNSUPPORTED --md -DDEVICE_PWMOUT=1 -DDEVICE_SERIAL_ASYNCH=1 --gnu --apcs=interwork -DDEVICE_SPI=1 -D__MBED__=1 -DTARGET_STM32L1 -DTARGET_STM32L152RE -DDEVICE_SERIAL=1 -DTARGET_M3 -DTARGET_CORTEX -DDEVICE_I2CSLAVE=1 -D__CMSIS_RTOS -DDEVICE_SPI_ASYNCH=1 -D__MBED_CMSIS_RTOS_CM
  c include: .; SX1276Lib; SX1276Lib/registers; SX1276Lib/sx1276; SX1276Lib/enums; SX1276Lib/debug; SX1276Lib/typedefs; SX1276Lib/radio; mbed/.; mbed/TARGET_NUCLEO_L152RE; mbed/TARGET_NUCLEO_L152RE/TARGET_STM; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/device; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/device; mbed/TARGET_NUCLEO_L152RE/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform
  asm misc: --cpreproc --cpreproc_opts=-D__ASSERT_MSG,-D__CMSIS_RTOS,-D__MBED_CMSIS_RTOS_CM,-D__CORTEX_M3,-DARM_MATH_CM3
  asm include: .; SX1276Lib; SX1276Lib/registers; SX1276Lib/sx1276; SX1276Lib/enums; SX1276Lib/debug; SX1276Lib/typedefs; SX1276Lib/radio; mbed/.; mbed/TARGET_NUCLEO_L152RE; mbed/TARGET_NUCLEO_L152RE/TARGET_STM; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/device; mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/device; mbed/TARGET_NUCLEO_L152RE/TOOLCHAIN_ARM_STD; mbed/drivers; mbed/hal; mbed/platform;
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  memory RVCT10: RAM 0x1fffe000 size 0x2000
  scatter file: mbed/TARGET_NUCLEO_L152RE/TOOLCHAIN_ARM_STD/stm32l152re.sct
  link misc: --show_full_path
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h DirHandle.h Ethernet.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemLike.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LocalFileSystem.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h PortIn.h PortInOut.h PortOut.h PwmOut.h RawSerial.h Serial.h SerialBase.h SPI.h SPISlave.h Stream.h Ticker.h Timeout.h Timer.h TimerEvent.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h dma_api.h Driver_Common.h Driver_Storage.h emac_api.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h lp_ticker_api.h pinmap.h port_api.h pwmout_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_NUCLEO_L152RE/TOOLCHAIN_ARM_STD/: analogin_api.o analogout_api.o can_api.o cmsis_nvic.o gpio_api.o gpio_irq_api.o gpio_irq_device.o hal_tick_16b.o hal_tick_32b.o i2c_api.o lp_ticker.o mbed.ar mbed_board.o mbed_overrides.o mbed_retarget.o PeripheralPins.o pinmap.o port_api.o pwmout_api.o pwmout_device.o rtc_api.o serial_api.o sleep.o spi_api.o startup_stm32l152xe.o stm32l1xx_hal.o stm32l1xx_hal_adc.o stm32l1xx_hal_adc_ex.o stm32l1xx_hal_comp.o stm32l1xx_hal_cortex.o stm32l1xx_hal_crc.o stm32l1xx_hal_cryp.o stm32l1xx_hal_cryp_ex.o stm32l1xx_hal_dac.o stm32l1xx_hal_dac_ex.o stm32l1xx_hal_dma.o stm32l1xx_hal_flash.o stm32l1xx_hal_flash_ex.o stm32l1xx_hal_flash_ramfunc.o stm32l1xx_hal_gpio.o stm32l1xx_hal_i2c.o stm32l1xx_hal_i2s.o stm32l1xx_hal_irda.o stm32l1xx_hal_iwdg.o stm32l1xx_hal_lcd.o stm32l1xx_hal_nor.o stm32l1xx_hal_opamp.o stm32l1xx_hal_opamp_ex.o stm32l1xx_hal_pcd.o stm32l1xx_hal_pcd_ex.o stm32l1xx_hal_pwr.o stm32l1xx_hal_pwr_ex.o stm32l1xx_hal_rcc.o stm32l1xx_hal_rcc_ex.o stm32l1xx_hal_rtc.o stm32l1xx_hal_rtc_ex.o stm32l1xx_hal_sd.o stm32l1xx_hal_smartcard.o stm32l1xx_hal_spi.o stm32l1xx_hal_spi_ex.o stm32l1xx_hal_sram.o stm32l1xx_hal_tim.o stm32l1xx_hal_tim_ex.o stm32l1xx_hal_uart.o stm32l1xx_hal_usart.o stm32l1xx_hal_wwdg.o stm32l1xx_ll_adc.o stm32l1xx_ll_comp.o stm32l1xx_ll_crc.o stm32l1xx_ll_dac.o stm32l1xx_ll_dma.o stm32l1xx_ll_exti.o stm32l1xx_ll_fsmc.o stm32l1xx_ll_gpio.o stm32l1xx_ll_i2c.o stm32l1xx_ll_opamp.o stm32l1xx_ll_pwr.o stm32l1xx_ll_rcc.o stm32l1xx_ll_rtc.o stm32l1xx_ll_sdmmc.o stm32l1xx_ll_spi.o stm32l1xx_ll_tim.o stm32l1xx_ll_usart.o stm32l1xx_ll_utils.o stm_spi_api.o sys.o system_stm32l1xx.o trng_api.o us_ticker_16b.o us_ticker_32b.o
    mbed/TARGET_NUCLEO_L152RE/: arm_common_tables.h arm_const_structs.h arm_math.h core_ca9.h core_ca_mmu.h core_caFunc.h core_caInstr.h core_cm0.h core_cm0plus.h core_cm3.h core_cm4.h core_cm4_simd.h core_cm7.h core_cmFunc.h core_cmInstr.h core_cmSecureAccess.h core_cmSimd.h core_sc000.h core_sc300.h
    mbed/platform/: Callback.h CallChain.h CircularBuffer.h critical.h CThunk.h FunctionPointer.h mbed_application.h mbed_assert.h mbed_critical.h mbed_debug.h mbed_error.h mbed_interface.h mbed_mem_trace.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_wait_api.h platform.h PlatformMutex.h rtc_time.h semihost_api.h SingletonPtr.h sleep.h toolchain.h Transaction.h wait_api.h
    mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/device/: cmsis.h cmsis_nvic.h hal_tick.h stm32l152xe.h stm32l1xx.h system_stm32l1xx.h
    mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/: common_objects.h device.h gpio_irq_device.h i2c_device.h pin_device.h pwmout_device.h
    mbed/TARGET_NUCLEO_L152RE/TARGET_STM/: gpio_object.h mbed_rtx.h PeripheralPins.h PinNamesTypes.h PortNames.h rtc_api_hal.h
    mbed/: mbed.h
    mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/TARGET_NUCLEO_L152RE/: objects.h PeripheralNames.h PinNames.h
    mbed/TARGET_NUCLEO_L152RE/TARGET_STM/TARGET_STM32L1/device/: stm32_hal_legacy.h stm32l1xx_hal.h stm32l1xx_hal_adc.h stm32l1xx_hal_adc_ex.h stm32l1xx_hal_comp.h stm32l1xx_hal_comp_ex.h stm32l1xx_hal_conf.h stm32l1xx_hal_cortex.h stm32l1xx_hal_crc.h stm32l1xx_hal_cryp.h stm32l1xx_hal_cryp_ex.h stm32l1xx_hal_dac.h stm32l1xx_hal_dac_ex.h stm32l1xx_hal_def.h stm32l1xx_hal_dma.h stm32l1xx_hal_flash.h stm32l1xx_hal_flash_ex.h stm32l1xx_hal_flash_ramfunc.h stm32l1xx_hal_gpio.h stm32l1xx_hal_gpio_ex.h stm32l1xx_hal_i2c.h stm32l1xx_hal_i2s.h stm32l1xx_hal_irda.h stm32l1xx_hal_iwdg.h stm32l1xx_hal_lcd.h stm32l1xx_hal_nor.h stm32l1xx_hal_opamp.h stm32l1xx_hal_opamp_ex.h stm32l1xx_hal_pcd.h stm32l1xx_hal_pcd_ex.h stm32l1xx_hal_pwr.h stm32l1xx_hal_pwr_ex.h stm32l1xx_hal_rcc.h stm32l1xx_hal_rcc_ex.h stm32l1xx_hal_rtc.h stm32l1xx_hal_rtc_ex.h stm32l1xx_hal_sd.h stm32l1xx_hal_smartcard.h stm32l1xx_hal_spi.h stm32l1xx_hal_spi_ex.h stm32l1xx_hal_sram.h stm32l1xx_hal_tim.h stm32l1xx_hal_tim_ex.h stm32l1xx_hal_uart.h stm32l1xx_hal_usart.h stm32l1xx_hal_wwdg.h stm32l1xx_ll_adc.h stm32l1xx_ll_bus.h stm32l1xx_ll_comp.h stm32l1xx_ll_cortex.h stm32l1xx_ll_crc.h stm32l1xx_ll_dac.h stm32l1xx_ll_dma.h stm32l1xx_ll_exti.h stm32l1xx_ll_fsmc.h stm32l1xx_ll_gpio.h stm32l1xx_ll_i2c.h stm32l1xx_ll_iwdg.h stm32l1xx_ll_opamp.h stm32l1xx_ll_pwr.h stm32l1xx_ll_rcc.h stm32l1xx_ll_rtc.h stm32l1xx_ll_sdmmc.h stm32l1xx_ll_spi.h stm32l1xx_ll_system.h stm32l1xx_ll_tim.h stm32l1xx_ll_usart.h stm32l1xx_ll_utils.h stm32l1xx_ll_wwdg.h
  group SX1276_SMS
    ./: main.cpp main.h mbed_config.h
  group SX1276Lib
    SX1276Lib/debug/: debug.h
    SX1276Lib/enums/: enums.h
    SX1276Lib/radio/: radio.cpp radio.h
    SX1276Lib/sx1276/: sx1276-hal.cpp sx1276-hal.h sx1276.cpp sx1276.h
    SX1276Lib/registers/: sx1276Regs-Fsk.h sx1276Regs-LoRa.h
    SX1276Lib/typedefs/: typedefs.h
